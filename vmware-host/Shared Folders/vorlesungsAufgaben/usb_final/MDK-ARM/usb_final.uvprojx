# Keil uVision project usb_final.uvprojx, settings and files
target usb_final (ARM-ADS)
  device: STM32F413ZHTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: usb_final +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F413xx
  c include: ../../../../../Inc;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/User
    ../../../../../Src/: main.c usbh_diskio.c fatfs.c usb_host.c usbh_conf.c usbh_platform.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../../../../../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Host_Library
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 4.3.0
